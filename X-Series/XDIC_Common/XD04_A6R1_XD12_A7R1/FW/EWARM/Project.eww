<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\XD04_A6R1_XD12_A7R1.ewp</path>
  </project>
  <batchBuild />
</workspace>
