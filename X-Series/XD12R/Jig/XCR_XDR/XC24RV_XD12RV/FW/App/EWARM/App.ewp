# IAR project App.ewp, settings and files
configuration App (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F446xx; XC_MODEL_TYPE=0; XC_REVISION=0; XD_MODEL_TYPE=0; XD_REVISION=1
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; C:\working\01_Project\FW\X-Series\XD12R\Jig\XCR_XDR\XC24RV_XD12RV\FW\App\user\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: App.bin
  prebuild: py "..\..\Prebuild\prebuild.py"
  ILINK.IlinkOutputFile: App.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration App_XCR24_ XDR12R (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\user\inc
configuration App_XCR24_ XDR12D (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F446xx; XC_MODEL_TYPE=0; XC_REVISION=0; XD_MODEL_TYPE=1; XD_REVISION=1
  ICCARM.CCIncludePath2: as above
configuration App_IC603_IC601 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F446xx; XC_MODEL_TYPE=1; XC_REVISION=0; XD_MODEL_TYPE=2; XD_REVISION=1
  ICCARM.CCIncludePath2: as above
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_adc.c stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group User/app
    ../user/app/: mgr_app.c
  group User/det
    ../user/det/: mgr_det.c
  group User/drvs
    ../user/drvs/: ads124s08.c crc.c drv_gpio.c drv_spi.c drv_timer.c drv_xcr24.c drv_xdr12.c ldim_conversion.c
  group User/framework
    ../user/framework/: fw_internal.h fw_main.c fw_memory.c fw_thread.c
  group User/Inc
    ../user/Inc/: ads124s08.h comm_debugging.h crc.h drv_comm.h drv_gpio.h drv_spi.h drv_timer.h drv_xcr24.h drv_xdr12.h framework.h ic601_es0_struct.h ic603_struct.h ldim_conversion.h version.h xcr24_struct.h xcr_struct.h xdr12_es1_struct.h xdr12_struct.h xdr12d_es1_struct.h xdr12r_es1_struct.h
  group User/Src
    ../user/Src/: comm_debugging.c
  group User/test
    ../user/test/: mgr_test.c
  group User/trim
    ../user/trim/: mgr_trim.c
