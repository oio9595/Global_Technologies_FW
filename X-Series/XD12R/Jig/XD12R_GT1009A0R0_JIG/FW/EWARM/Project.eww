<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\XD12R_GT1009A0R0.ewp</path>
  </project>
  <batchBuild />
</workspace>
