<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\XD12R_GT1009A0R0_REL.ewp</path>
  </project>
  <batchBuild />
</workspace>
