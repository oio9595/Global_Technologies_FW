<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\xdic_led_module_control_bd.ewp</path>
  </project>
  <batchBuild />
</workspace>
